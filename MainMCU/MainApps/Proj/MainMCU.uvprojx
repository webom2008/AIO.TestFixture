# Keil uVision project MainMCU.uvprojx, settings and files
target MainMCU (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MainMCU +hex
  AfterMake: ..\Binary\hex2bin.exe ..\Obj\MainMCU.hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\BoardCfg;..\StmLib\STM32F10x_StdPeriph_Driver\inc;..\StmLib\CMSIS;..\FreeRTOS\include;..\FreeRTOS\portable\Keil\ARM_CM3;..\Embedded\utilities;..\Embedded\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StmLib
    ../StmLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../StmLib/CMSIS/: core_cm3.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/Keil/ARM_CM3/: port.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group BoardCfg
    ../BoardCfg/: FreeRTOSConfig.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group Embedded
    ../Embedded/platform/: main.c version.c MyTimer.c
    ../Embedded/utilities/: fifo.c defines.h fifo.h includes.h sysconfigs.h crc.c printf-stdarg.c
  group Drivers
    ../Embedded/drivers/src/: drivers.c i2c_common.c spi_common.c uart_common.c driver_uart1.c driver_uart2.c driver_uart3.c driver_uart4.c driver_uart5.c driver_aioboard.c driver_buzzer.c driver_keys.c driver_leds.c driver_dac.c driver_interAdc.c driver_dpy.c driver_secur.c
  group Apps
    ../Embedded/apps/: drivers_test.c AppCoopMCU.c CoopMcuProtocol.c AioStmUpdate.c AppTestedAIO.c AioDspProtocol.c AppPC.c ComputerProtocol.c AppTaskUtilities.c AppGeneralIO.c AlarmSystem.c AppMainProcess.c testFunctions.c
